# IAR project BasicSetup.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32L476xx
  ICCARM.CCIncludePath2: ../../Drivers/CMSIS/Include; ../../Drivers/CMSIS/ST/STM32L4xx/Include; ../../Lib/Inc; Core/Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
    ../../Drivers/CMSIS/ST/STM32L4xx/Source/: startup_stm32l476xx.s system_stm32l4xx.c
    ../../../../Cortex-M4/Projects/BlinkLED1/Core/Src/: stm32l4xx_it.c
